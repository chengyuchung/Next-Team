# Keil uVision project Project.uvprojx, settings and files
target GD32A711x_A712x_M7_0 (6240000::V6.24::ARMCLANG)
  device: GD32A712AI:CM7_0 GigaDevice
  pack: GigaDevice.GD32A7xx_DFP.0.4.1
  cpu: IRAM(0x24000000,0x28000) IRAM2(0x00000000,0x8000) IROM(0x08000000,0x200000) IROM2(0x08800000,0x20000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32A711X_A712X
  c misc: -Wassign-enum
  c include: ..\..\..\..\Library\Firmware\CMSIS;..\..\..\..\Library\Firmware\CMSIS\GD\GD32A7xx\Include;..\..\..\..\Library\Firmware\GD32A7xx_standard_peripheral\Include;..\..\..\..\Library\Utilities;..\..\Template_SingleCore;..\..\..\Third_party\FreeRTOS-10.3.1\portable\GCC\ARM_CM4F;..\..\..\Third_party\FreeRTOS-10.3.1\include;..\..\Template_SingleCore\MCAL;..\..\Template_SingleCore\App;..\..\Template_SingleCore\BSW\EcuAL;..\..\Template_SingleCore\BSW\Services
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x8800000 size 0x20000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x24000000 size 0x28000
  memory RVCT10: RAM 0x0 size 0x8000
  group Application
    ../: gd32a7xx_it.c main.c systick.c
  group App
    ../App/: app_tasks.c can_app.c thermal_control.c power_mode.c ignition_control.c
  group CMSIS
    ../../../../Library/Firmware/CMSIS/GD/GD32A7xx/Source/: gd32a7xx_err_report.c system_gd32a71xx_a74xx.c
  group Peripherals
    ../../../../Library/Firmware/GD32A7xx_standard_peripheral/Source/: gd32a7xx_adc.c gd32a7xx_bkp.c gd32a7xx_busim.c gd32a7xx_can.c gd32a7xx_cltcfg.c gd32a7xx_cmp.c gd32a7xx_crc.c gd32a7xx_dac.c gd32a7xx_dbg.c gd32a7xx_dma.c gd32a7xx_enet.c gd32a7xx_exti.c gd32a7xx_extmpu.c gd32a7xx_fmc.c gd32a7xx_fmu.c gd32a7xx_fwdgt.c gd32a7xx_gdap.c gd32a7xx_gpio.c gd32a7xx_hsmif.c gd32a7xx_hwsem.c gd32a7xx_i2c.c gd32a7xx_imicu.c gd32a7xx_ioc.c gd32a7xx_irm.c gd32a7xx_jdc.c gd32a7xx_linflexd_lin.c gd32a7xx_linflexd_uart.c gd32a7xx_mcmu.c gd32a7xx_mfcom.c gd32a7xx_misc.c gd32a7xx_mtc.c gd32a7xx_pmu.c gd32a7xx_prpu.c gd32a7xx_qspi.c gd32a7xx_rcu.c gd32a7xx_rtc.c gd32a7xx_sent.c gd32a7xx_spi.c gd32a7xx_sram_tcm.c gd32a7xx_stcm.c gd32a7xx_syscfg.c gd32a7xx_timer.c gd32a7xx_trigsel.c gd32a7xx_wwdgt.c
  group Startup
    ../../../../Library/Firmware/CMSIS/GD/GD32A7xx/Source/ARM/: startup_gd32a711x_a712x.s
  group Utilities
    ../../../../Library/Utilities/: gd32a712_evb.c
  group FreeRTOS
    ../../../Third_party/FreeRTOS-10.3.1/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../Third_party/FreeRTOS-10.3.1/portable/GCC/ARM_CM4F/: port.c
    ../../../Third_party/FreeRTOS-10.3.1/portable/MemMang/: heap_4.c
  group MCAL
    ../MCAL/: adc_manager.c can_driver.c power_manager.c bmp280.c ds18b20.c mq9_mcal.c key.c motor_pwm_gd32.c relay_power.c watchdog.c actor_hal.c i2c.c
  group BSW::ECUAL
    ../BSW/EcuAL/: adc_ecual.c pressure_sensor.c gas_sensor.c temp_sensor.c
  group BSW::Services
    ../BSW/Services/: can_protocol.c system_state.c fault_manager.c sensor_manager.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.4.0
